# IAR project stcpu-f4xx-std-v1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG; STM32F40_41xxx; USE_STDPERIPH_DRIVER; FreeRTOS_Kernel; UART_TRACE
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\src\Chip\PeriphDriver\inc; ..\..\src\Chip\STM32F40x\Comm\inc; ..\..\src\Chip\STM32F40x\CMSIS\Device\inc; ..\..\src\Chip\STM32F40x\STM32F4x7_ETH_Driver; ..\..\src\Chip\STM32F40x\STM32F4xx_StdPeriph_Driver\inc; ..\..\src\Comm\utlis\inc; ..\..\src\Comm\utlis\inc\trace; ..\..\src\Comm\utlis\inc\trace\RTT; ..\..\src\3rdPart\LwIP\netif; ..\..\src\3rdPart\LwIP\include; ..\..\src\3rdPart\LwIP\netif\ports; ..\..\src\3rdPart\LwIP\include\ipv4; ..\..\src\3rdPart\Kernel\cfg; ..\..\src\3rdPart\Kernel\inc; ..\..\src\3rdPart\Kernel\ports\IAR; ..\..\src\3rdPart\STemWin\inc; ..\..\src\3rdPart\STemWin\Cfg; ..\..\src\Comm\Param\inc; ..\..\src\Comm\Protocol\inc; ..\..\src\Core\inc
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: FreeRTOS_Kernel
  AARM.AUserIncludes: ..\..\src\3rdPart\Kernel\cfg
  OBJCOPY.OOCOutputFile: stcpu-f4xx-std-v1.bin
  ILINK.IlinkOutputFile: cc.out
  ILINK.IlinkIcfFile: ..\..\src\Chip\STM32F40x\CMSIS\Linker\Chip.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F40_41xxx; USE_STDPERIPH_DRIVER; FreeRTOS_Kernel; STemWin_GUI; UART_TRACE
  ILINK.IlinkOutputFile: stcpu-cm-v2.out
  group 3rdpart/kernel/cfg
    ../../src/3rdPart/Kernel/cfg/: FreeRTOSConfig.h Kernel.c Kernel.h os_app_hook.c
  group 3rdpart/kernel/ports
    ../../src/3rdPart/Kernel/ports/: heap_4.c
    ../../src/3rdPart/Kernel/ports/IAR/: port.c portasm.s portmacro.h
  group 3rdpart/kernel/src
    ../../src/3rdPart/Kernel/src/: croutine.c list.c queue.c tasks.c tasktimers.c
  group 3rdpart/lwip/api
    ../../src/3rdPart/LwIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group 3rdpart/lwip/core
    ../../src/3rdPart/LwIP/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group 3rdpart/lwip/core/ipv4
    ../../src/3rdPart/LwIP/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group 3rdpart/lwip/netif
    ../../src/3rdPart/LwIP/netif/: etharp.c
  group 3rdpart/lwip/netif/arch
    ../../src/3rdPart/LwIP/netif/arch/: sys_arch.c
  group 3rdpart/lwip/netif/ports
    ../../src/3rdPart/LwIP/netif/ports/: ethernetif.c lwipopts.h
  group app
    ./: appcfg.h AppCore.c main.c main.h stm32f4xx_conf.h
  group chip/periphdriver
    ../../src/Chip/PeriphDriver/src/: ETH_EMAC.c Flash.c FlashCfg.c MemMgr.c SRAM.c
  group chip/periphdriver/rfid
    ../../src/Chip/PeriphDriver/src/RFID/: FM17xx.c MFRC522.c RFIDCfg.c
  group chip/stm32f4xx/cmsis
    ../../src/Chip/STM32F40x/CMSIS/Device/src/: startup_stm32f40_41xxx.s stm32f4xx_it.c system_stm32f4xx_IAR.c
  group chip/stm32f4xx/comm
    ../../src/Chip/STM32F40x/Comm/src/: CAN.c GPIO.c NVIC.c RTC.c SPI.c StartUpCfg.c TimDly.c UART4.c USART1.c
  group chip/stm32f4xx/ethDriver
    ../../src/Chip/STM32F40x/STM32F4x7_ETH_Driver/: stm32f4x7_eth.c stm32f4x7_eth_conf.h
  group chip/stm32f4xx/StdPeriph_Driver
    ../../src/Chip/STM32F40x/STM32F4xx_StdPeriph_Driver/src/: STM32F4xxStdPeriphLib.a
  group comm/param
    ../../src/Comm/Param/src/: Param.c
    ../../src/Comm/Param/inc/: ParamCfg.h
  group comm/utils
    ../../src/Comm/utlis/src/: FSMBuffer.c
  group comm/utils/libs
    ../../src/Comm/utlis/src/: libs.c utils.c
  group comm/utils/trace
    ../../src/Comm/utlis/src/trace/: trace.c
  group comm/utils/trace/rtt
    ../../src/Comm/utlis/src/trace/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group core/msg
    ../../src/Core/src/msg/: MsgMnt.c
  group core/net
    ../../src/Core/src/net/: netio.c netmnt.c
  group note
    ../Tools/: iar.txt
    ../Tools/doc/note/: Note.txt
